<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SDR_usrp</value></param>
<param><key>author</key><value>David Candal</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>SDR ZigBee</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>TFG</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_ack</value></param>
<param><key>value</key><value>0x0</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 5,7,1,2</value></param>
<param><key>label</key><value>"Campo ACK"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_bloque</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 5,5,1,2</value></param>
<param><key>label</key><value>"No bloque"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>APS_cabeceraExtendida</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 2,5,1,1</value></param>
<param><key>label</key><value>"Cab extendida"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_cluster</value></param>
<param><key>value</key><value>0XABCD</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 4,0,1,3</value></param>
<param><key>label</key><value>"ID cluster"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_endpointDestino</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 3,3,1,3</value></param>
<param><key>label</key><value>"Endpoint destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_endpointOrigen</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 3,0,1,3</value></param>
<param><key>label</key><value>"Endpoint origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_ack</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,8,1,2</value></param>
<param><key>label</key><value>"Campo ACK"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_bloque</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,4,1,2</value></param>
<param><key>label</key><value>"No bloque"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_cabeceraExtendida</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 2,6,1,3</value></param>
<param><key>label</key><value>"Cab extendida"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_cluster</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 4,0,1,3</value></param>
<param><key>label</key><value>"ID cluster"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_counter</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 5,0,1,3</value></param>
<param><key>label</key><value>"Contador"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_endpointDestino</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 3,6,1,3</value></param>
<param><key>label</key><value>"Endpoint destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_endpointOrigen</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 3,0,1,3</value></param>
<param><key>label</key><value>"Endpoint origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_formatoACK</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 1,0,1,3</value></param>
<param><key>label</key><value>"Formato ACK"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_fragmentado</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,0,1,2</value></param>
<param><key>label</key><value>"C extendida"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_grupo</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 5,6,1,3</value></param>
<param><key>label</key><value>"Direccion grupo"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_modo</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 0,6,1,3</value></param>
<param><key>label</key><value>"Modo de entrega"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_perfil</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 4,6,1,3</value></param>
<param><key>label</key><value>"ID perfil"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_seguridad</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 1,6,1,3</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_solicitaACK</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 2,0,1,3</value></param>
<param><key>label</key><value>"Solicita ACK"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>APS_etq_tipoTrama</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 0,0,1,3</value></param>
<param><key>label</key><value>"Tipo de trama"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>APS_formatoACK</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 1,2,1,1</value></param>
<param><key>label</key><value>"Formato ACK"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>APS_fragmentado</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 5,0,1,5</value></param>
<param><key>label0</key><value>"Sin fragmentar"</value></param>
<param><key>label1</key><value>"1er fragmento"</value></param>
<param><key>label2</key><value>"Fragmentado"</value></param>
<param><key>label</key><value>"C extendida"</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_grupo</value></param>
<param><key>value</key><value>0x1234</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 3,6,1,3</value></param>
<param><key>label</key><value>"Direccion grupo"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>APS_modo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@2: 0,4,1,4</value></param>
<param><key>label0</key><value>"Unicast"</value></param>
<param><key>label1</key><value>"Unicast indirecto"</value></param>
<param><key>label2</key><value>"Broadcast"</value></param>
<param><key>label3</key><value>"Grupo"</value></param>
<param><key>label</key><value>"Modo de entrega"</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>APS_perfil</value></param>
<param><key>value</key><value>0xDCBA</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 4,3,1,3</value></param>
<param><key>label</key><value>"ID perfil"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>APS_seguridad</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 1,5,1,1</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>APS_solicitaACK</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@2 : 2,2,1,1</value></param>
<param><key>label</key><value>"Solicita ACK"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>APS_tipoTrama</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@2: 0,0,1,4</value></param>
<param><key>label0</key><value>"Datos"</value></param>
<param><key>label1</key><value>"Comando"</value></param>
<param><key>label2</key><value>"ACK"</value></param>
<param><key>label</key><value>"Tipo de trama"</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>LedGreen</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>Tab@2 : 0,1,1,1</value></param>
<param><key>label</key><value>Led verde</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>MAC_dirDestino</value></param>
<param><key>value</key><value>0x0101010101010101</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 5,1,1,1</value></param>
<param><key>label</key><value>"Direccion destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>MAC_dirOrigen</value></param>
<param><key>value</key><value>0x1010101010101010</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 5,0,1,1</value></param>
<param><key>label</key><value>"Direccion origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_dirDestino</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 5,2,1,1</value></param>
<param><key>label</key><value>"Direccion destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_dirOrigen</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 5,0,1,1</value></param>
<param><key>label</key><value>"Direccion origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_intraPAN</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 2,2,1,1</value></param>
<param><key>label</key><value>"IntraPAN"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_modoDest</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 3,2,1,1</value></param>
<param><key>label</key><value>"Modo direcc (destino)"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_modoSrc</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 3,0,1,1</value></param>
<param><key>label</key><value>"Modo direcc (origen)"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_numSeq</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 0,2,1,1</value></param>
<param><key>label</key><value>"Num de secuencia"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_panDestino</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 4,2,1,1</value></param>
<param><key>label</key><value>"PAN destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_panOrigen</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 4,0,1,1</value></param>
<param><key>label</key><value>"PAN origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_payload</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 0,0,1,1</value></param>
<param><key>label</key><value>"Carga"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_reqACK</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 2,0,1,1</value></param>
<param><key>label</key><value>"Solicita ACK"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_seguridad</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 1,0,1,1</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_tipoTrama</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 0,0,1,1</value></param>
<param><key>label</key><value>"Tipo de trama"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>MAC_etq_tramaPendiente</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 1,2,1,1</value></param>
<param><key>label</key><value>"Trama pendiente"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>MAC_intraPAN</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 2,1,1,1</value></param>
<param><key>label</key><value>"IntraPAN"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>MAC_modoDest</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 3,1,1,1</value></param>
<param><key>label0</key><value>"Desactivada"</value></param>
<param><key>label1</key><value>"Direccion corta"</value></param>
<param><key>label2</key><value>"Direccion larga"</value></param>
<param><key>label</key><value>"Modo direc destino"</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>MAC_modoSrc</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 3,0,1,1</value></param>
<param><key>label0</key><value>"Desactivada"</value></param>
<param><key>label1</key><value>"Direccion corta"</value></param>
<param><key>label2</key><value>"Direccion larga"</value></param>
<param><key>label</key><value>"Modo direc origen"</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>MAC_panDestino</value></param>
<param><key>value</key><value>0xDCBA</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 4,1,1,1</value></param>
<param><key>label</key><value>"PAN destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>MAC_panOrigen</value></param>
<param><key>value</key><value>0xABCD</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 4,0,1,1</value></param>
<param><key>label</key><value>"PAN origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>MAC_reqACK</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 2,0,1,1</value></param>
<param><key>label</key><value>"Solicita ACK"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>MAC_seguridad</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 1,0,1,1</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>MAC_tipoTrama</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 0,0,1,1</value></param>
<param><key>label0</key><value>"Beacon"</value></param>
<param><key>label1</key><value>"Datos"</value></param>
<param><key>label2</key><value>"ACK"</value></param>
<param><key>label3</key><value>"Comando MAC"</value></param>
<param><key>label</key><value>"Tipo de trama"</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>MAC_tramaPendiente</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@0 : 1,1,1,1</value></param>
<param><key>label</key><value>"Trama pendiente"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_Multicast</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 1,2,1,2</value></param>
<param><key>label</key><value>"Multicast"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_descRuta</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 1,0,1,2</value></param>
<param><key>label</key><value>"Descubrimiento de ruta"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_dirDestino</value></param>
<param><key>value</key><value>0x2222</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 5,2,1,2</value></param>
<param><key>label</key><value>"Direccion destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_dirIEEEDst</value></param>
<param><key>value</key><value>0x0101010101010101</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 6,3,1,3</value></param>
<param><key>label</key><value>"IEEE destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_dirIEEESrc</value></param>
<param><key>value</key><value>0x1010101010101010</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 6,0,1,3</value></param>
<param><key>label</key><value>"IEEE origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_dirOrigen</value></param>
<param><key>value</key><value>0x1111</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 5,0,1,2</value></param>
<param><key>label</key><value>"Direccion origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_direccionesSR</value></param>
<param><key>value</key><value>0xDCBA,0XABCD</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 8,0,1,6</value></param>
<param><key>label</key><value>"Source route"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_descRuta</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 1,0,1,3</value></param>
<param><key>label</key><value>"Descubrimiento ruta"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_dirDestino</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 4,6,1,3</value></param>
<param><key>label</key><value>"Direccion destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_dirIeeeDst</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 6,6,1,3</value></param>
<param><key>label</key><value>"IEEE destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_dirIeeeOrg</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 6,0,1,3</value></param>
<param><key>label</key><value>"IEEE origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_dirOrigen</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 4,0,1,3</value></param>
<param><key>label</key><value>"Direccion origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_direccionesSR</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 8,0,1,3</value></param>
<param><key>label</key><value>"Source route"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_ieeeDst</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 3,6,1,3</value></param>
<param><key>label</key><value>"IEEE destino"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_ieeeSrc</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 3,0,1,3</value></param>
<param><key>label</key><value>"IEEE origen"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_mcastRadio</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,4,1,2</value></param>
<param><key>label</key><value>"Radio mcast"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_mcastRadioMax</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,8,1,2</value></param>
<param><key>label</key><value>"Radio mcast max"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_modomulticast</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,0,1,2</value></param>
<param><key>label</key><value>"Multicast"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_multicast</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 1,6,1,3</value></param>
<param><key>label</key><value>"Multicast"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_numSeq</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 0,6,1,3</value></param>
<param><key>label</key><value>"Numero de secuecia"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_radio</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 5,0,1,3</value></param>
<param><key>label</key><value>"Radio"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_seguridad</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 2,0,1,3</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_sourceRoute</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 2,6,1,3</value></param>
<param><key>label</key><value>"Source route"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>NWK_etq_tipoTrama</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 0,0,1,3</value></param>
<param><key>label</key><value>"Tipo trama"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_ieeeDst</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 2,4,1,2</value></param>
<param><key>label</key><value>"IEEE destino"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_ieeeSrc</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 2,2,1,2</value></param>
<param><key>label</key><value>"IEEE origen"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_mcastRadio</value></param>
<param><key>value</key><value>7</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 7,2,1,2</value></param>
<param><key>label</key><value>"Radio mcast"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_mcastRadioMax</value></param>
<param><key>value</key><value>7</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 7,4,1,2</value></param>
<param><key>label</key><value>"Radio mcast max"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>NWK_modoMulticast</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 7,0,1,2</value></param>
<param><key>label0</key><value>"No miembro"</value></param>
<param><key>label1</key><value>"Miembro"</value></param>
<param><key>label</key><value>"Multicast"</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_radio</value></param>
<param><key>value</key><value>7</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 5,4,1,2</value></param>
<param><key>label</key><value>"Radio"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_seguridad</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 1,4,1,2</value></param>
<param><key>label</key><value>"Seguridad"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>NWK_sourceRoute</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>Tabtx@1 : 2,0,1,2</value></param>
<param><key>label</key><value>"Source route"</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>NWK_tipoTrama</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>Tabtx@1: 0,0,1,3</value></param>
<param><key>label0</key><value>"Datos"</value></param>
<param><key>label1</key><value>"Comando"</value></param>
<param><key>label</key><value>"Tipo de trama"</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>enviar</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>Tab@0 : 99,0,1,3</value></param>
<param><key>label</key><value>Enviar</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Canal</value></param>
<param><key>labels</key><value>["11","12","13","14","15","16","17","18","19","20","21","22","23","24","25","26","27"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ganancia TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>labelSensor</value></param>
<param><key>value</key><value></value></param>
<param><key>gui_hint</key><value>Tab@2 : 1,0,1,1</value></param>
<param><key>label</key><value>Sensor</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ledRed</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>Tab@2 : 0,0,1,1</value></param>
<param><key>label</key><value>Led rojo</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ledYellow</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>Tab@2 : 0,2,1,1</value></param>
<param><key>label</key><value>Led amarillo</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>"Ejemplo"</value></param>
<param><key>gui_hint</key><value>Tab@0 : 0,0,1,1</value></param>
<param><key>label</key><value>"Carga"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_ack</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,10,1,2</value></param>
<param><key>key</key><value>aps_ack</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_bloque</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,6,1,2</value></param>
<param><key>key</key><value>aps_bloque</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_cabeceraExtendida</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 2,9,1,3</value></param>
<param><key>key</key><value>aps_cabeceraExtendida</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_cluster</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 4,3,1,3</value></param>
<param><key>key</key><value>aps_cluster</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_counter</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 5,3,1,3</value></param>
<param><key>key</key><value>aps_counter</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_endpointDestino</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 3,9,1,3</value></param>
<param><key>key</key><value>aps_endpointDestino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_endpointOrigen</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 3,3,1,3</value></param>
<param><key>key</key><value>aps_endpointOrigen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_formatoACK</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 1,3,1,3</value></param>
<param><key>key</key><value>aps_formatoACK</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_fragmentado</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 6,2,1,2</value></param>
<param><key>key</key><value>aps_fragmentado</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_grupo</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 5,9,1,3</value></param>
<param><key>key</key><value>aps_grupo</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_modo</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 0,9,1,3</value></param>
<param><key>key</key><value>aps_modo</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_perfil</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 4,9,1,3</value></param>
<param><key>key</key><value>aps_perfil</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_seguridad</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 1,9,1,3</value></param>
<param><key>key</key><value>aps_seguridad</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_solicitaACK</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 2,3,1,3</value></param>
<param><key>key</key><value>aps_solicitaACK</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>APS_msg_tipoTrama</value></param>
<param><key>gui_hint</key><value>Tabrx@2 : 0,3,1,3</value></param>
<param><key>key</key><value>aps_tipoTrama</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_dirDestino</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 5,3,1,1</value></param>
<param><key>key</key><value>mac_dirDestino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_dirOrigen</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 5,1,1,1</value></param>
<param><key>key</key><value>mac_dirOrigen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_intraPAN</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 2,3,1,1</value></param>
<param><key>key</key><value>mac_intrapan</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_modoDest</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 3,3,1,1</value></param>
<param><key>key</key><value>mac_modoDest</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_modoSrc</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 3,1,1,1</value></param>
<param><key>key</key><value>mac_modoSrc</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_numSeq</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 0,3,1,1</value></param>
<param><key>key</key><value>mac_numSeq</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_panDestino</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 4,3,1,1</value></param>
<param><key>key</key><value>mac_panDestino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_panOrigen</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 4,1,1,1</value></param>
<param><key>key</key><value>mac_panOrigen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_payload</value></param>
<param><key>gui_hint</key><value>Tab@1 : 0,1,1,3</value></param>
<param><key>key</key><value>"payload"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_reqACK</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 2,1,1,1</value></param>
<param><key>key</key><value>mac_reqACK</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_seguridad</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 1,1,1,1</value></param>
<param><key>key</key><value>mac_seguridad</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_tipoTrama</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 0,1,1,1</value></param>
<param><key>key</key><value>mac_tipoTrama</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>MAC_msg_tramaPendiente</value></param>
<param><key>gui_hint</key><value>Tabrx@0 : 1,3,1,1</value></param>
<param><key>key</key><value>mac_tramaPendiente</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_descRuta</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 1,3,1,3</value></param>
<param><key>key</key><value>nwk_descRuta</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_dirDestino</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 4,9,1,3</value></param>
<param><key>key</key><value>nwk_dirDestino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_dirIeeeDst</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 6,9,1,3</value></param>
<param><key>key</key><value>nwk_dirIeeeDst</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_dirIeeeOrg</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 6,3,1,3</value></param>
<param><key>key</key><value>nwk_dirIeeeOrg</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_dirOrigen</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 4,3,1,3</value></param>
<param><key>key</key><value>nwk_dirOrigen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_direccionesSR</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 8,3,1,9</value></param>
<param><key>key</key><value>nwk_direccionesSR</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_ieeeDst</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 3,9,1,3</value></param>
<param><key>key</key><value>nwk_ieeeDst</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_ieeeSrce</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 3,3,1,3</value></param>
<param><key>key</key><value>nwk_ieeeSrce</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_mcastRadio</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,6,1,2</value></param>
<param><key>key</key><value>nwk_mcastRadio</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_mcastRadioMax</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,10,1,2</value></param>
<param><key>key</key><value>nwk_mcastRadioMax</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_modomulticast</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 7,2,1,2</value></param>
<param><key>key</key><value>nwk_modomulticast</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_multicast</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 1,9,1,3</value></param>
<param><key>key</key><value>nwk_multicast</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_numSeq</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 0,9,1,3</value></param>
<param><key>key</key><value>nwk_numSeq</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_radio</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 5,3,1,3</value></param>
<param><key>key</key><value>nwk_radio</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_seguridad</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 2,3,1,3</value></param>
<param><key>key</key><value>nwk_seguridad</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_sourceRoute</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 2,9,1,3</value></param>
<param><key>key</key><value>nwk_sourceRoute</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_msg_tipoTrama</value></param>
<param><key>gui_hint</key><value>Tabrx@1 : 0,3,1,3</value></param>
<param><key>key</key><value>nwk_tipoTrama</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Tab</value></param>
<param><key>label0</key><value>Transmision</value></param>
<param><key>label1</key><value>Recepcion</value></param>
<param><key>label2</key><value>Motas</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Tabrx</value></param>
<param><key>gui_hint</key><value>Tab@1: 1,0,1,4</value></param>
<param><key>label0</key><value>MAC</value></param>
<param><key>label1</key><value>NWK</value></param>
<param><key>label2</key><value>APS</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Tabtx</value></param>
<param><key>gui_hint</key><value>Tab@0 : 1,0,1,1</value></param>
<param><key>label0</key><value>MAC</value></param>
<param><key>label1</key><value>NWK</value></param>
<param><key>label2</key><value>APS</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/sdr.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>10</value></param>
<param><key>delay</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>sensor</value></param>
<param><key>gui_hint</key><value>Tab@2 : 1,1,1,2</value></param>
<param><key>key</key><value>sensor</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>tfg_APS_stack</key>
<param><key>id</key><value>tfg_APS_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>tfg_Aplication</key>
<param><key>id</key><value>tfg_Aplication_0</value></param>
</block>
<block>
<key>tfg_MAC_stack</key>
<param><key>id</key><value>tfg_MAC_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>tfg_NWK_stack</key>
<param><key>id</key><value>tfg_NWK_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>tfg_MAC_stack_0</sink_block_id><source_key>rxout</source_key><sink_key>in(PHY)</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tfg_APS_stack_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(NWK)</source_key><sink_key>in(APS)</sink_key></connection>
<connection><source_block_id>tfg_APS_stack_0</source_block_id><sink_block_id>tfg_Aplication_0</sink_block_id><source_key>out(ZCL)</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_ack</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_bloque</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_cabeceraExtendida</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_cluster</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_counter</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_endpointDestino</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_endpointOrigen</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_formatoACK</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_fragmentado</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_grupo</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_modo</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_perfil</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_seguridad</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_solicitaACK</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>APS_msg_tipoTrama</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_dirDestino</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_dirOrigen</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_intraPAN</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_modoDest</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_modoSrc</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_numSeq</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_panDestino</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_panOrigen</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_payload</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_reqACK</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_seguridad</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_tipoTrama</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>MAC_msg_tramaPendiente</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_descRuta</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_dirDestino</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_dirIeeeDst</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_dirIeeeOrg</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_dirOrigen</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_direccionesSR</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_ieeeDst</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_ieeeSrce</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_mcastRadio</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_mcastRadioMax</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_modomulticast</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_multicast</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_numSeq</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_radio</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_seguridad</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_sourceRoute</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_msg_tipoTrama</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>sensor</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>out</source_key><sink_key>in(ZCL)</sink_key></connection>
<connection><source_block_id>tfg_MAC_stack_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(NWK)</source_key><sink_key>in(MAC)</sink_key></connection>
<connection><source_block_id>tfg_MAC_stack_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>out(PHY)</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tfg_MAC_stack_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>out(PHY)</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>out(APS)</source_key><sink_key>in(NWK)</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_MAC_stack_0</sink_block_id><source_key>out(MAC)</source_key><sink_key>in(NWK)</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
