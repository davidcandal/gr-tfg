<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SDR_QT</value></param>
<param><key>author</key><value>David Candal</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>SDR ZigBee</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>TFG</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Endpoint_dst</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>Tab@0 : 2,2,1,1</value></param>
<param><key>label</key><value>"Endpoint destino"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Endpoint_src</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>Tab@0 : 2,0,1,1</value></param>
<param><key>label</key><value>"Endpoint origen"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_add_dst</value></param>
<param><key>value</key><value>0xDCBA</value></param>
<param><key>gui_hint</key><value>Tab@0 : 1,2,1,1</value></param>
<param><key>label</key><value>"Direccion NWK destino"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>NWK_add_src</value></param>
<param><key>value</key><value>0xABCD</value></param>
<param><key>gui_hint</key><value>Tab@0 : 1,0,1,1</value></param>
<param><key>label</key><value>"Direccion NWK origen"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cluster</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 3,0,1,1</value></param>
<param><key>label</key><value>ID de cluster</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>clusterID</value></param>
<param><key>value</key><value>0xABCD</value></param>
<param><key>gui_hint</key><value>Tab@0 : 3,0,1,1</value></param>
<param><key>label</key><value>"ID de cluster"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>endpoint_dst</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 2,2,1,1</value></param>
<param><key>label</key><value>Endpoint destino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>endpoint_src</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 2,0,1,1</value></param>
<param><key>label</key><value>Enpoint origen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>enviar</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>Tab@0 : 7,0,1,3</value></param>
<param><key>label</key><value>Enviar</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Canal</value></param>
<param><key>labels</key><value>["11","12","13","14","15","16","17","18","19","20","21","22","23","24","25","26","27"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ganancia TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_nwk_dst</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 1,2,1,1</value></param>
<param><key>label</key><value>Direccion NWK destino</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_nwk_src</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 1,0,1,1</value></param>
<param><key>label</key><value>Direccion NWK origen</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>label_payload</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 0,0,1,1</value></param>
<param><key>label</key><value>Carga</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>nseq</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 4,0,1,1</value></param>
<param><key>label</key><value>Numero de secuencia</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>"EJEMPLO"</value></param>
<param><key>gui_hint</key><value>Tab@0 : 0,0,1,3</value></param>
<param><key>label</key><value>Carga del mensaje</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>profile</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>Tab@1 : 3,2,1,1</value></param>
<param><key>label</key><value>ID de perfil</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>profileID</value></param>
<param><key>value</key><value>0xDCBA</value></param>
<param><key>gui_hint</key><value>Tab@0 : 3,2,1,1</value></param>
<param><key>label</key><value>"ID de perfil"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_add_dst_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 1,3,1,1</value></param>
<param><key>key</key><value>"NWK_add_dst"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>NWK_add_src_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 1,1,1,1</value></param>
<param><key>key</key><value>"NWK_add_src"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Tab</value></param>
<param><key>label0</key><value>Transmision</value></param>
<param><key>label1</key><value>Recepcion</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/sensor.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>cluster_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 3,1,1,1</value></param>
<param><key>key</key><value>"cluster"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>endpoint_dst_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 2,3,1,1</value></param>
<param><key>key</key><value>"endpoint_dst"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>endpoint_src_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 2,1,1,1</value></param>
<param><key>key</key><value>"endpoint_src"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>10</value></param>
<param><key>delay</key><value>True</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>nseq_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 4,1,1,1</value></param>
<param><key>key</key><value>"nseq"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>payload_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 0,1,1,3</value></param>
<param><key>key</key><value>"payload"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>perfl_r</value></param>
<param><key>gui_hint</key><value>Tab@1 : 3,3,1,1</value></param>
<param><key>key</key><value>"perfil"</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>tfg_APS_stack</key>
<param><key>id</key><value>tfg_APS_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>tfg_Aplication</key>
<param><key>id</key><value>tfg_Aplication_0</value></param>
</block>
<block>
<key>tfg_NWK_stack</key>
<param><key>id</key><value>tfg_NWK_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
<param><key>sourceIEEE</key><value>0xF0E1D2C3B4A59788</value></param>
<param><key>sourceAdd</key><value>NWK_add_src</value></param>
</block>
<block>
<key>tfg_translation_block</key>
<param><key>id</key><value>tfg_translation_block_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>tfg_translation_block_0</sink_block_id><source_key>app out</source_key><sink_key>in(bastibl)</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>pdu out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tfg_APS_stack_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(NWK)</source_key><sink_key>in(APS)</sink_key></connection>
<connection><source_block_id>tfg_APS_stack_0</source_block_id><sink_block_id>tfg_Aplication_0</sink_block_id><source_key>out(ZCL)</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_add_dst_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>NWK_add_src_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>cluster_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>endpoint_dst_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>endpoint_src_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>nseq_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>payload_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>perfl_r</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>tfg_Aplication_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>out</source_key><sink_key>in(ZCL)</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>out(APS)</source_key><sink_key>in(NWK)</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_translation_block_0</sink_block_id><source_key>out(MAC)</source_key><sink_key>in(david)</sink_key></connection>
<connection><source_block_id>tfg_translation_block_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>out(bastibl)</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>tfg_translation_block_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(david)</source_key><sink_key>in(MAC)</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
