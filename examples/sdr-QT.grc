<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SDR_QT_pruebas</value></param>
<param><key>author</key><value>David Candal</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>SDR ZigBee</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>TFG</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/sensor.pcap</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>foo_packet_pad</key>
<param><key>id</key><value>foo_packet_pad_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.1</value></param>
<param><key>delay</key><value>True</value></param>
<param><key>pad_front</key><value>2000</value></param>
<param><key>pad_tail</key><value>2000</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>tech</key><value>195</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>tfg_APS_stack</key>
<param><key>id</key><value>tfg_APS_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>tfg_NWK_stack</key>
<param><key>id</key><value>tfg_NWK_stack_0</value></param>
<param><key>debugInput</key><value>True</value></param>
<param><key>debugOutput</key><value>False</value></param>
</block>
<block>
<key>tfg_mac</key>
<param><key>id</key><value>tfg_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>tfg_test_aps</key>
<param><key>id</key><value>tfg_test_aps_0</value></param>
</block>
<block>
<key>tfg_translation_block</key>
<param><key>id</key><value>tfg_translation_block_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>tfg_test_aps_0</sink_block_id><source_key>strobe</source_key><sink_key>entrada</sink_key></connection>
<connection><source_block_id>foo_packet_pad_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_wireshark_connector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_wireshark_connector_0</sink_block_id><source_key>rxout</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>tfg_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>foo_packet_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tfg_APS_stack_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(NWK)</source_key><sink_key>in(APS)</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>out(APS)</source_key><sink_key>in(NWK)</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_0</source_block_id><sink_block_id>tfg_translation_block_0</sink_block_id><source_key>out(MAC)</source_key><sink_key>in(david)</sink_key></connection>
<connection><source_block_id>tfg_mac_0</source_block_id><sink_block_id>tfg_translation_block_0</sink_block_id><source_key>app out</source_key><sink_key>in(bastibl)</sink_key></connection>
<connection><source_block_id>tfg_mac_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>tfg_test_aps_0</source_block_id><sink_block_id>tfg_APS_stack_0</sink_block_id><source_key>salida</source_key><sink_key>in(ZCL)</sink_key></connection>
<connection><source_block_id>tfg_translation_block_0</source_block_id><sink_block_id>tfg_mac_0</sink_block_id><source_key>out(bastibl)</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>tfg_translation_block_0</source_block_id><sink_block_id>tfg_NWK_stack_0</sink_block_id><source_key>out(david)</source_key><sink_key>in(MAC)</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
