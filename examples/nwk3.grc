<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nwk3</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>tfg_NWK_stack_constructor</key>
<param><key>id</key><value>tfg_NWK_stack_constructor_0</value></param>
<param><key>sourceIEEE</key><value>0x24</value></param>
<param><key>sourceAdd</key><value>0x12</value></param>
</block>
<block>
<key>tfg_imprimir_bytes</key>
<param><key>id</key><value>tfg_imprimir_bytes_0</value></param>
</block>
<block>
<key>tfg_test_nwk</key>
<param><key>id</key><value>tfg_test_nwk_0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>tfg_test_nwk_0</sink_block_id><source_key>strobe</source_key><sink_key>entrada</sink_key></connection>
<connection><source_block_id>tfg_NWK_stack_constructor_0</source_block_id><sink_block_id>tfg_imprimir_bytes_0</sink_block_id><source_key>out(MAC)</source_key><sink_key>entrada</sink_key></connection>
<connection><source_block_id>tfg_test_nwk_0</source_block_id><sink_block_id>tfg_NWK_stack_constructor_0</sink_block_id><source_key>salida</source_key><sink_key>in(APS)</sink_key></connection>
</flow_graph>
